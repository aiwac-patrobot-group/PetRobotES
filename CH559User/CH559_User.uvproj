# Keil uVision project CH559_User.uvproj, settings and files
target CH559 (MCS-51)
  device: SST89E564RD SST
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) CLOCK(40000000)
  output: CH559_DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\User\Device;..\User\Host;..\User;..\User\PUB;..\User\PUB\INC;..\CH559User;.\myInclude
  group CH559
    ./: CH559_DEMO.C
